Commit message: add planr move

File: urdf/cubic_planar.xacro.urdf (robot description, URDF)
Before this commit: robot cube_bot, 2 links, 1 joints
Joints:
- joint world_to_cube: type prismatic -> planar
